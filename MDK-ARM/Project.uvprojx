# Keil uVision project Project.uvprojx, settings and files
target X-9700H_2.4G_BT_V1_0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32F103C8T MindMotion
  pack: MindMotion.MM32F103_DFP.1.4.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: X-9700H_2.4G_BT_V1_0 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,F103_N_VERSION
  c include: ..\Application;..\..\..\..\MM32_Drivers\CMSIS\Device\MM\MM32F103\Include;..\..\..\..\MM32_Drivers\CMSIS\Include;..\..\..\..\MM32_Drivers\MM32F103_standard_peripheral\inc;..\Common;..\BSP;..\FIFO;..\SEGGER_RTT_V512\RTT;..\DLList;..\BSP\SD-MG1S02;..\BSP\W25Q16;..\BSP\HID\inc;..\..\..\..\MM32_Drivers\MM32F103_usbd_driver\Include;..\BSP\RFID;..\BSP\YMSCCD20;..\BSP\Wireless\misc;..\BSP\Wireless\misc\Utf2Gbk\inc;..\BSP\XN297l;..\BSP\FSC-BT826;..\BSP\3800B;..\BSP\i435e-S
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x200000
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep Music.o
  group Application/MDK-ARM
    ../Application/: startup_MM32F103.s
  group Drivers/CMSIS
    ../Application/: system_MM32F103.c
  group Drivers/MM32F103_standard_peripheral
    ../../../../MM32_Drivers/MM32F103_standard_peripheral/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
    ../../../../MM32_Drivers/MM32F103_standard_peripheral/inc/: HAL_adc.h HAL_bkp.h HAL_can.h HAL_conf.h HAL_crc.h HAL_dac.h HAL_dma.h HAL_exti.h HAL_flash.h HAL_gpio.h HAL_i2c.h HAL_iwdg.h HAL_misc.h HAL_pwr.h HAL_rcc.h HAL_rtc.h HAL_spi.h HAL_tim.h HAL_uart.h HAL_wwdg.h
  group Drivers/MM32F103_usbd_driver
    ../../../../MM32_Drivers/MM32F103_usbd_driver/Source/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Common
    ../Common/: Common.h
  group BSP/MG1S02
    ../BSP/SD-MG1S02/: MG1S02.c MG1S02.h UART0.c UART0.h
  group BSP/W25Q16
    ../BSP/W25Q16/: W25Q16.c W25Q16.h
  group BSP/YMSCCD20
    ../BSP/YMSCCD20/: YMSCCD20.c YMSCCD20.h UART1.c UART1.h
  group BSP/RFID
    ../BSP/RFID/: RFID.c RFID.h
  group BSP/HID
    ../BSP/HID/src/: hw_config.c usb_desc.c usb_endp.c usb_iap.c usb_istr.c usb_prop.c usb_pwr.c
  group BSP/3800B
    ../BSP/3800B/: 3800B.c 3800B.h UART1.c UART1.h
  group BSP/Wireless
    ../BSP/Wireless/misc/Utf2Gbk/src/: ascii.c ces_gbk.c cp936.c cp936ext.c EncodeDataExtract.c gb2312.c gbk.c gbkext_inv.c gbkext1.c gbkext2.c utf8.c
    ../BSP/Wireless/misc/: drv_flash.c drv_spi.c drv_uart.c ring_buffer.c W25Qxx.c
  group BSP/XN297l
    ../BSP/XN297l/: rf_cmd.c rf_hal.c rf_main.c XN297L.c
  group BSP/BSC-BT826
    ../BSP/FSC-BT826/: bluetooth.c UART2.c
  group BSP/i435e
    ../BSP/i435e-S/: i435e.c UART2.c
  group BSP
    ../BSP/: BSP.c BSPTimer.c BSPSystem.c BSPBeep.c BSPPower.c BSPKey.c BSPLED.c BSPFlash.c BSPHID.c BSPCodeScanner.c BSPWireless.c BSPWatchDog.c BSPSound.c BSPSound.h BSPEEPROM.c
  group Middle/FIFO
    ../FIFO/: FIFO.h FIFO.lib
  group Middle/DLList
    ../DLList/: DLList.h DLList.lib
  group Application/RTT
    ../SEGGER_RTT_V512/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Application/User
    ../Application/: main.c mm32f10x_it.c ascii2hid.c
  group Resource
    ../Resource/: Music.c
